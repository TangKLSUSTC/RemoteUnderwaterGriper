# Keil uVision project water_griper_slave_v1.1debug.uvprojx, settings and files
target watergriper_slave_v1.0debug (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: water_griper_v1.0debug +hex
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,USE_RTT,WG_SLAVE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Core\Hardware;..\Core\RT_Thread\include;..\Core\RT_Thread\include\libc;..\Core\RT_Thread\user;..\Core\RT_Thread\components\finsh;..\Core\board;..\Core\BSP;..\Core\Easyflash\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP/Config
    ../Core/BSP/: bsp_config.h mini_f103c8t6.c
    ../Core/RT_Thread/user/: rtconfig.h board.c
    ../Core/Hardware/: myconsole.c
  group PrivateCode
    ../Core/board/: IO_def.c
    ../Core/Hardware/: IO_config.c controller.c my_ringbuf_8bit.c data_req.c bit_io.c watergriper.c
  group Hardware
    ../Core/Hardware/: sys.c led.c
  group RT/source
    ../Core/RT_Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT/Ports
    ../Core/RT_Thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group RT/Components
    ../Core/RT_Thread/components/finsh/: cmd.c msh.c shell.c
target watergriper_master_v1.0debug (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: water_griper_v1.0debug +hex
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,USE_RTT,WG_MASTER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0
